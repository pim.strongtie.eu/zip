Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T13:13:29
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 13:13:29 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{10796E15-250E-4E41-818C-FE43E675894C}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 13:13:29 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 13:13:29 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 13:13:29 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Normal Holes\RFA 3D\GSE380_74_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Symbol at End 1 Default: no; Line Weight: 1; Symbol at End 2 Default: yes; Line Pattern: -3000010; Color: 0
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: GSE380_74_4, GSE380_74_4:GSE380_74_4:106297
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.00599016 ft3
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE380/74/4
Materials and Finishes - Product Material: Galvanised
Identity Data - Description: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; ObjectType: GSE380/74/4; Model: GSE380/74/4; Manufacturer: Simpson Strong-Tie; UniClass Title: Joist hangers; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Number: Pr_20_29_31_44; Model ID: 0167559818778083327613004514442237464453; Copyright: ©Simpson Strong-Tie; Product Type: Joist hanger; Name: GSE380/74/4; URL: www.strongtie.eu; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors
General - Density: 1.25; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GSE380/74/4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
