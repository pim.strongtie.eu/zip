Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T13:13:44
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 13:13:44 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{A3E3158E-E1B0-4C08-9F13-2E437D07638D}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 13:13:44 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 13:13:44 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 13:13:44 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Normal Holes\RFA 3D\GSE380_122_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Graphics - Line Pattern: -3000010; Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Color: 0; Line Weight: 1

# IfcBuildingElementProxy: GSE380_122_4, GSE380_122_4:GSE380_122_4:121369
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00599016 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE380/122/4
Identity Data - OmniClass Title: Wood Connectors; Description: Joist hanger; Model: GSE380/122/4; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Number: 23.20.40.11.24.14; Product Type: Joist hanger; Manufacturer: Simpson Strong-Tie; ObjectType: GSE380/122/4; Name: GSE380/122/4; UniClass Number: Pr_20_29_31_44; Model ID: 0167559818778083327613004514442237464453; Copyright: ©Simpson Strong-Tie; URL: www.strongtie.eu; UniClass Title: Joist hangers; Model Disclaimer: Contact Simpson Strong-Tie Company for more information
General - Reference: GSE380/122/4; Density: 1.25; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Materials and Finishes - Product Material: Galvanised
