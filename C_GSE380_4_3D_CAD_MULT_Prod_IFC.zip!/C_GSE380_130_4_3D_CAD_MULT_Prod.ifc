Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T13:13:46
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 13:13:46 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{185633BF-6AFA-4FE1-B3B3-1CBFB3027F04}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 13:13:46 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 13:13:46 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 13:13:46 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Normal Holes\RFA 3D\GSE380_130_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Weight: 1; Symbol at End 2 Default: yes; Line Pattern: -3000010; Symbol at End 1 Default: no

# IfcBuildingElementProxy: GSE380_130_4, GSE380_130_4:GSE380_130_4:123881
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00599016 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE380/130/4
General - EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE380/130/4; Density: 1.25; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Manufacturer: Simpson Strong-Tie; Copyright: ©Simpson Strong-Tie; Model ID: 0167559818778083327613004514442237464453; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Name: GSE380/130/4; OmniClass Number: 23.20.40.11.24.14; Model: GSE380/130/4; Description: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; ObjectType: GSE380/130/4; Product Type: Joist hanger; URL: www.strongtie.eu; OmniClass Title: Wood Connectors; UniClass Title: Joist hangers; UniClass Number: Pr_20_29_31_44
Materials and Finishes - Product Material: Galvanised
