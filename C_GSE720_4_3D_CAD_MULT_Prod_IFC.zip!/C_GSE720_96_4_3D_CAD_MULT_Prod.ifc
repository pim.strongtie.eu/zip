Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-05T09:20:28
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 05 09:20:28 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{3F0A4535-53E5-47A3-817A-49D51CF17F2D}\ifc * Database version: 5507 * Database creation date: Tue Sep 05 09:20:28 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 05 09:20:28 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 05 09:20:28 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\5th 425 Models\Normal Holes\RFA 3D\C_GSE720_96_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Line Weight: 1; Symbol at End 2 Default: yes; Color: 0; Line Pattern: -3000010; Symbol at End 1 Default: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: C_GSE720_96_4_3D_CAD_MULT_Prod, C_GSE720_96_4_3D_CAD_MULT_Prod:C_GSE720_96_4_3D_CAD_MULT_Prod:113205
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.0112433 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: ___
Identity Data - Copyright: ©Simpson Strong-Tie; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Title: Wood Connectors; OmniClass Number: 23.20.40.11.24.14; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; URL: www.strongtie.eu; UniClass Title: Bracketed angle supports; UniClass Number: Pr_20_85_09_09; Manufacturer: Simpson Strong-Tie
General - Density: 0; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: ___; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Materials and Finishes - Product Material: Galvanised
