Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-14T15:22:48
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 14 15:22:48 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{A7D16A1E-83E1-4AD6-9AD3-044B8792722E}\ifc * Database version: 5507 * Database creation date: Thu Sep 14 15:22:48 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 14 15:22:48 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 14 15:22:48 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Final Documents\2023-9-13 the last 255 models of batch 1.3\3D Contents\Remove Holes\C_GSE960_68_4_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Graphics - Symbol at End 2 Default: yes; Line Weight: 1; Symbol at End 1 Default: no; Color: 0; Line Pattern: -3000010

# IfcBuildingElementProxy: C_GSE960_68_4_3D_CAD_MULT_Prod_noholes, C_GSE960_68_4_3D_CAD_MULT_Prod_noholes:C_GSE960_68_4_3D_CAD_MULT_Prod_noholes:211154
In: Level 1
Material: Galvanized
Dimensions - Volume: 0.0152796 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie Company Inc.
Pset_BuildingElementProxyCommon - Reference: C_GSE960_68_4_3D_CAD_MULT_Prod_noholes
Identity Data - Provide Feedback: http://www.strongtie.com/drawings/revit_request.asp; Copyright: ©Simpson Strong-Tie; Model ID: 0272150146917317630433385560729309714891; URL: http://www.strongtie.com/; Model: GSE960/68/4; Model Disclaimer: Contact Simpson Strong-Tie Company Inc. for more information; Product Type: Joist hanger; Manufacturer: Simpson Strong-Tie Company Inc.
Materials and Finishes - Product Material: Galvanized
