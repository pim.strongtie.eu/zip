Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-05T09:24:19
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 05 09:24:19 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{996E7D21-5EF9-4D82-A992-918BA7D85818}\ifc * Database version: 5507 * Database creation date: Tue Sep 05 09:24:19 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 05 09:24:19 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 05 09:24:19 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\5th 425 Models\Normal Holes\RFA 3D\C_GSE900_164_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Weight: 1

# IfcBuildingElementProxy: C_GSE900_164_4_3D_CAD_MULT_Prod, C_GSE900_164_4_3D_CAD_MULT_Prod:C_GSE900_164_4_3D_CAD_MULT_Prod:294697
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.0140436 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: ___
Identity Data - OmniClass Number: 23.20.40.11.24.14; URL: www.strongtie.eu; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Bracketed angle supports; UniClass Number: Pr_20_85_09_09; Manufacturer: Simpson Strong-Tie; OmniClass Title: Wood Connectors; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Copyright: ©Simpson Strong-Tie
General - Reference: ___; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 0; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Materials and Finishes - Product Material: Galvanised
