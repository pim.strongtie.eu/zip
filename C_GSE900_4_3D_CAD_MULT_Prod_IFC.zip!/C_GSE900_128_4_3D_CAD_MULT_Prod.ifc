Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-05T09:24:04
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 05 09:24:04 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{779EB67A-BE9C-4048-AE3B-7A15A8E57C47}\ifc * Database version: 5507 * Database creation date: Tue Sep 05 09:24:04 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 05 09:24:04 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 05 09:24:04 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\5th 425 Models\Normal Holes\RFA 3D\C_GSE900_128_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Weight: 1; Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Line Pattern: -3000010

# IfcBuildingElementProxy: C_GSE900_128_4_3D_CAD_MULT_Prod, C_GSE900_128_4_3D_CAD_MULT_Prod:C_GSE900_128_4_3D_CAD_MULT_Prod:283393
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.0140427 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: ___
Identity Data - URL: www.strongtie.eu; Copyright: ©Simpson Strong-Tie; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Number: Pr_20_85_09_09; Manufacturer: Simpson Strong-Tie; UniClass Title: Bracketed angle supports; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Title: Wood Connectors; OmniClass Number: 23.20.40.11.24.14
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: ___; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 0
Materials and Finishes - Product Material: Galvanised
