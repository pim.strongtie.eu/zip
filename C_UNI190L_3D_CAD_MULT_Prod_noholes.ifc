Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-08-28T15:44:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 28 15:44:21 2026 * Host: 105VN714 * Database: C:\Users\KHUNGU~1\AppData\Local\Temp\{D8E28A15-89B4-4570-AC8E-2380AD07D8FE}\ifc * Database version: 5507 * Database creation date: Fri Aug 28 15:44:20 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 28 15:44:21 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 28 15:44:21 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: D:\BIMCAD EU\ES-26080486 EU BIM files for Missing angle brackets\3D Contents - No Holes\RFA 3D\C_UNI190L_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: C_UNI190L_3D_CAD_MULT_Prod_noholes, C_UNI190L_3D_CAD_MULT_Prod_noholes:C_UNI190L_3D_CAD_MULT_Prod_noholes:92731
In: Level 1
Type - Material: Galvanised
Type - Constraints - Default Elevation: 0 mm
Type - General - Density: 0.204; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: UNI190L; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Type - Identity Data - Copyright: ©Simpson Strong-Tie; Description: Angle brackets; Manufacturer: Simpson Strong-Tie; Model: UNI190L; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0186596196659679956615469473300645435102; Name: UNI190L; ObjectType: UNI190L; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Angle brackets; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: C_UNI190L_3D_CAD_MULT_Prod_noholes; UniClass Number: Pr_20_85_09_09; UniClass Title: Bracketed angle supports; URL: www.strongtie.eu
Type - Materials and Finishes - Product Material: Galvanised
Type - Other - Category: Structural Connections; Family Name: C_UNI190L_3D_CAD_MULT_Prod_noholes
Pset_BuildingElementProxyCommon - Reference: UNI190L
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm
Dimensions - Volume: 0.0000259443 m3
Other - Family: C_UNI190L_3D_CAD_MULT_Prod_noholes: C_UNI190L_3D_CAD_MULT_Prod_noholes; Family and Type: C_UNI190L_3D_CAD_MULT_Prod_noholes: C_UNI190L_3D_CAD_MULT_Prod_noholes; Schedule Level: Level: Level 1; Type: C_UNI190L_3D_CAD_MULT_Prod_noholes: C_UNI190L_3D_CAD_MULT_Prod_noholes; Type Id: C_UNI190L_3D_CAD_MULT_Prod_noholes: C_UNI190L_3D_CAD_MULT_Prod_noholes
Phasing - Phase Created: New Construction
