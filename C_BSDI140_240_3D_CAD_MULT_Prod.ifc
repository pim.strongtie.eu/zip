Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-08-27T13:11:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 27 13:11:25 2026 * Host: 105VN714 * Database: C:\Users\KHUNGU~1\AppData\Local\Temp\{12B6A825-D9DC-4D50-A8F7-2AA6C42102C2}\ifc * Database version: 5507 * Database creation date: Thu Aug 27 13:11:24 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 27 13:11:25 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 27 13:11:25 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: D:\BIMCAD EU\ES-26080565 EU BIM files for Missing joist hnagers Priority 1\Working\3D Contents-Normal Holes\RFA 3D\C_BSDI140_240_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: C_BSDI140_240_3D_CAD_MULT_Prod, C_BSDI140_240_3D_CAD_MULT_Prod:C_BSDI140_240_3D_CAD_MULT_Prod:104350
In: Level 1
Type - Material: Galvanised
Type - Constraints - Default Elevation: 0 mm
Type - General - Density: 0.794; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: BSDI140/240; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Type - Identity Data - Copyright: ©Simpson Strong-Tie; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; Model: BSDI140/240; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0245211224339413909147799238122868698702; Name: BSDI140/240; ObjectType: BSDI140/240; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: C_BSDI140_240_3D_CAD_MULT_Prod; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; URL: www.strongtie.eu
Type - Materials and Finishes - Product Material: Galvanised
Type - Other - Category: Structural Connections; Family Name: C_BSDI140_240_3D_CAD_MULT_Prod
Pset_BuildingElementProxyCommon - Reference: BSDI140/240
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm
Dimensions - Volume: 0.0000893628 m3
Other - Family: C_BSDI140_240_3D_CAD_MULT_Prod: C_BSDI140_240_3D_CAD_MULT_Prod; Family and Type: C_BSDI140_240_3D_CAD_MULT_Prod: C_BSDI140_240_3D_CAD_MULT_Prod; Schedule Level: Level: Level 1; Type: C_BSDI140_240_3D_CAD_MULT_Prod: C_BSDI140_240_3D_CAD_MULT_Prod; Type Id: C_BSDI140_240_3D_CAD_MULT_Prod: C_BSDI140_240_3D_CAD_MULT_Prod
Phasing - Phase Created: New Construction
