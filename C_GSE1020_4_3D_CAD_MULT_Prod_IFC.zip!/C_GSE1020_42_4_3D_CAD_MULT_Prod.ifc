Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-17T16:38:22
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 17 16:38:22 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{85E4DD10-B815-4A22-B72A-78B4BFCA92C1}\ifc * Database version: 5507 * Database creation date: Mon Jul 17 16:38:22 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 17 16:38:22 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 17 16:38:22 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Normal Holes\RFA 3D\C_GSE1020_42_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Graphics - Line Weight: 1; Color: 0; Symbol at End 1 Default: no; Line Pattern: -3000010; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: C_GSE1020_42_4_3D_CAD_MULT_Prod, C_GSE1020_42_4_3D_CAD_MULT_Prod:C_GSE1020_42_4_3D_CAD_MULT_Prod:146489
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.015916 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE1020/42/4
Identity Data - UniClass Number: Pr_20_29_31_44; Model ID: 0021453351274842237233275995356361797366; Model: GSE1020/42/4; Name: GSE1020/42/4; UniClass Title: Joist hangers; Manufacturer: Simpson Strong-Tie; OmniClass Number: 23.20.40.11.24.14; Copyright: ©Simpson Strong-Tie; OmniClass Title: Wood Connectors; Description: Joist hanger; Product Type: Joist hanger; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; ObjectType: GSE1020/42/4; URL: www.strongtie.eu; Provide Feedback: mailto:EUdrawings@strongtie.com
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 3.4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE1020/42/4
Materials and Finishes - Product Material: Galvanised
