Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-17T16:39:02
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 17 16:39:02 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{8A497420-D006-4604-BE04-E7194237EF2A}\ifc * Database version: 5507 * Database creation date: Mon Jul 17 16:39:01 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 17 16:39:02 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 17 16:39:02 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Normal Holes\RFA 3D\C_GSE1020_154_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Graphics - Symbol at End 1 Default: no; Line Pattern: -3000010; Color: 0; Symbol at End 2 Default: yes; Line Weight: 1

# IfcBuildingElementProxy: C_GSE1020_154_4_3D_CAD_MULT_Prod, C_GSE1020_154_4_3D_CAD_MULT_Prod:C_GSE1020_154_4_3D_CAD_MULT_Prod:181657
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.0159117 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE1020/154/4
Identity Data - Model ID: 0238644756388094773612452428448615078849; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GSE1020/154/4; UniClass Title: Joist hangers; Product Type: Joist hanger; Description: Joist hanger; UniClass Number: Pr_20_29_31_44; OmniClass Number: 23.20.40.11.24.14; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Title: Wood Connectors; ObjectType: GSE1020/154/4; Name: GSE1020/154/4; Manufacturer: Simpson Strong-Tie; URL: www.strongtie.eu; Copyright: ©Simpson Strong-Tie
General - Density: 3.41; Reference: GSE1020/154/4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
