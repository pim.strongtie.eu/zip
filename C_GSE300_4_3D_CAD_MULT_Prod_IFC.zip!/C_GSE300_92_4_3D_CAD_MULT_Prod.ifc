Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-17T16:37:52
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 17 16:37:52 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{7F2CCE7A-E7CD-49E0-AB1B-6562104A6AF6}\ifc * Database version: 5507 * Database creation date: Mon Jul 17 16:37:52 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 17 16:37:52 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 17 16:37:52 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Normal Holes\RFA 3D\C_GSE300_92_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Line Weight: 1; Symbol at End 2 Default: yes; Color: 0; Line Pattern: -3000010

# IfcBuildingElementProxy: C_GSE300_92_4_3D_CAD_MULT_Prod, C_GSE300_92_4_3D_CAD_MULT_Prod:C_GSE300_92_4_3D_CAD_MULT_Prod:111949
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00477879 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE300/92/4
Identity Data - Model: GSE300/92/4; OmniClass Number: 23.20.40.11.24.14; UniClass Title: Joist hangers; ObjectType: GSE300/92/4; OmniClass Title: Wood Connectors; Copyright: ©Simpson Strong-Tie; Model ID: 0183248256365066923776616198262381326422; Manufacturer: Simpson Strong-Tie; Name: GSE300/92/4; Provide Feedback: mailto:EUdrawings@strongtie.com; URL: www.strongtie.eu; UniClass Number: Pr_20_29_31_44; Description: Joist hanger; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Product Type: Joist hanger
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GSE300/92/4; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.01; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Materials and Finishes - Product Material: Galvanised
