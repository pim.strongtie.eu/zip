Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-17T16:37:44
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 17 16:37:44 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{473EDA51-C043-4988-8769-6F2A6701B927}\ifc * Database version: 5507 * Database creation date: Mon Jul 17 16:37:44 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 17 16:37:44 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 17 16:37:44 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Normal Holes\RFA 3D\C_GSE300_60_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Line Weight: 1; Symbol at End 1 Default: no; Line Pattern: -3000010; Color: 0; Symbol at End 2 Default: yes
Dimensions - Computation Height: 0 mm
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Identity Data - Name: Level 1; Structural: no; Building Story: yes

# IfcBuildingElementProxy: C_GSE300_60_4_3D_CAD_MULT_Prod, C_GSE300_60_4_3D_CAD_MULT_Prod:C_GSE300_60_4_3D_CAD_MULT_Prod:101901
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00477879 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE300/60/4
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GSE300/60/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.01
Identity Data - Manufacturer: Simpson Strong-Tie; Description: Joist hanger; OmniClass Number: 23.20.40.11.24.14; Copyright: ©Simpson Strong-Tie; UniClass Title: Joist hangers; Product Type: Joist hanger; ObjectType: GSE300/60/4; Model: GSE300/60/4; UniClass Number: Pr_20_29_31_44; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0183248256365066923776616198262381326422; URL: www.strongtie.eu; OmniClass Title: Wood Connectors; Provide Feedback: mailto:EUdrawings@strongtie.com; Name: GSE300/60/4
Materials and Finishes - Product Material: Galvanised
