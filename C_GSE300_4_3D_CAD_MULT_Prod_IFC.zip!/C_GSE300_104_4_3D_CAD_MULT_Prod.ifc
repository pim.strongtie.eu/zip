Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-17T16:37:55
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 17 16:37:55 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{BFCA6370-BF0F-4293-B1CD-2923D7AC801D}\ifc * Database version: 5507 * Database creation date: Mon Jul 17 16:37:55 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 17 16:37:55 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 17 16:37:55 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Normal Holes\RFA 3D\C_GSE300_104_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Graphics - Line Weight: 1; Symbol at End 2 Default: yes; Line Pattern: -3000010; Symbol at End 1 Default: no; Color: 0

# IfcBuildingElementProxy: C_GSE300_104_4_3D_CAD_MULT_Prod, C_GSE300_104_4_3D_CAD_MULT_Prod:C_GSE300_104_4_3D_CAD_MULT_Prod:115717
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00477882 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE300/104/4
Identity Data - Model ID: 0021453351274842237233275995356361797366; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Description: Joist hanger; OmniClass Title: Wood Connectors; Model: GSE300/104/4; Manufacturer: Simpson Strong-Tie; Name: GSE300/104/4; OmniClass Number: 23.20.40.11.24.14; ObjectType: GSE300/104/4; Provide Feedback: mailto:EUdrawings@strongtie.com; Copyright: ©Simpson Strong-Tie; Product Type: Joist hanger; UniClass Number: Pr_20_29_31_44; URL: www.strongtie.eu; UniClass Title: Joist hangers
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.01; Reference: GSE300/104/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Materials and Finishes - Product Material: Galvanised
