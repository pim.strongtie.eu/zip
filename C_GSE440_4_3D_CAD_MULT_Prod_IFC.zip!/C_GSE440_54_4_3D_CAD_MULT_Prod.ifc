Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T13:13:55
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 13:13:55 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{B16FA1FD-3682-478F-B4D7-74AAF60AF3E2}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 13:13:55 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 13:13:55 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 13:13:55 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Normal Holes\RFA 3D\GSE440_54_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Line Weight: 1; Color: 0; Symbol at End 1 Default: no; Line Pattern: -3000010; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: GSE440_54_4, GSE440_54_4:GSE440_54_4:133301
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00692155 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE440/54/4
Identity Data - Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Title: Wood Connectors; ObjectType: GSE440/54/4; URL: www.strongtie.eu; Description: Joist hanger; UniClass Number: Pr_20_29_31_44; Product Type: Joist hanger; Copyright: ©Simpson Strong-Tie; Name: GSE440/54/4; UniClass Title: Joist hangers; OmniClass Number: 23.20.40.11.24.14; Model: GSE440/54/4; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Manufacturer: Simpson Strong-Tie; Model ID: 0106845967910967583169462323905988993325
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE440/54/4; EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.45
Materials and Finishes - Product Material: Galvanised
