Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-05-10T14:20:12
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri May 10 14:20:12 2024 * Host: 105VN585 * Database: C:\Users\KHUNGU~1\AppData\Local\Temp\{858A6634-1297-48E6-BEAB-6DE459A0E7F3}\ifc * Database version: 5507 * Database creation date: Fri May 10 14:20:11 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri May 10 14:20:12 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri May 10 14:20:12 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-243361 EU BIMCAD for Various products (55L, 66L, 66T etc ..)\Working\3D Contents\Normal holes\RFA 3D\A88.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Identity Data - Type Name: Level 1; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: A88, A88:A88:64380
In: Level 1
Material: Galvanised
Pset_BuildingElementProxyCommon - Reference: A88
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm; Work Plane: Level : Level 1; Default Elevation: 0 mm
Dimensions - Volume: 0.0000505493 m3
Other - Category: Structural Connections; Family: A88: A88; Family and Type: A88: A88; Schedule Level: Level: Level 1; Type: A88: A88; Type Id: A88: A88; Family Name: A88
Phasing - Phase Created: New Construction
General - Density: 0.93; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: A88; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Copyright: ©Simpson Strong-Tie; Description: Angle brackets; Manufacturer: Simpson Strong-Tie; Model: A88; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0248602488582063414368373340327691890095; Name: A88; ObjectType: A88; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Angle brackets; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: A88; UniClass Number: Pr_20_85_09_09; UniClass Title: Bracketed angle supports; URL: www.strongtie.eu
Materials and Finishes - Product Material: Galvanised

# IfcOpeningElement: Opening (14)
In: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Name (A88:A88:64380:...)
1
2
3
4
5
6
7
8
9
10
11
12
13
14
