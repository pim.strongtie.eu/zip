Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-05T09:25:44
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 05 09:25:44 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{F14F3385-074C-4036-BB0E-7E84401527CA}\ifc * Database version: 5507 * Database creation date: Tue Sep 05 09:25:44 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 05 09:25:44 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 05 09:25:44 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\5th 425 Models\Normal Holes\RFA 3D\C_GSE960_186_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Line Weight: 1; Color: 0; Symbol at End 2 Default: yes; Symbol at End 1 Default: no

# IfcBuildingElementProxy: C_GSE960_186_4_3D_CAD_MULT_Prod, C_GSE960_186_4_3D_CAD_MULT_Prod:C_GSE960_186_4_3D_CAD_MULT_Prod:354985
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.0149803 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: ___
Identity Data - UniClass Title: Bracketed angle supports; UniClass Number: Pr_20_85_09_09; OmniClass Title: Wood Connectors; Manufacturer: Simpson Strong-Tie; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Number: 23.20.40.11.24.14; Copyright: ©Simpson Strong-Tie; URL: www.strongtie.eu; Provide Feedback: mailto:EUdrawings@strongtie.com
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: ___; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 0
Materials and Finishes - Product Material: Galvanised
