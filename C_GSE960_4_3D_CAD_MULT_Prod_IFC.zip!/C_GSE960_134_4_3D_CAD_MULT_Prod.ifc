Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-05T09:25:21
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 05 09:25:21 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{C5D837B0-EFBB-4A9E-8035-8E74E580007E}\ifc * Database version: 5507 * Database creation date: Tue Sep 05 09:25:21 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 05 09:25:21 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 05 09:25:21 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\5th 425 Models\Normal Holes\RFA 3D\C_GSE960_134_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Pattern: -3000010

# IfcBuildingElementProxy: C_GSE960_134_4_3D_CAD_MULT_Prod, C_GSE960_134_4_3D_CAD_MULT_Prod:C_GSE960_134_4_3D_CAD_MULT_Prod:338657
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.0149794 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: ___
Identity Data - UniClass Title: Bracketed angle supports; Copyright: ©Simpson Strong-Tie; OmniClass Number: 23.20.40.11.24.14; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Number: Pr_20_85_09_09; URL: www.strongtie.eu; OmniClass Title: Wood Connectors; Provide Feedback: mailto:EUdrawings@strongtie.com; Manufacturer: Simpson Strong-Tie
General - Reference: ___; Density: 0; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Materials and Finishes - Product Material: Galvanised
