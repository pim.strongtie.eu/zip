Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-05T09:21:16
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 05 09:21:16 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{A32FB79C-09EA-4943-AAAB-FABA8C2404E2}\ifc * Database version: 5507 * Database creation date: Tue Sep 05 09:21:15 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 05 09:21:16 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 05 09:21:16 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\5th 425 Models\Normal Holes\RFA 3D\C_GSE780_52_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Graphics - Symbol at End 1 Default: no; Line Pattern: -3000010; Color: 0; Line Weight: 1; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: C_GSE780_52_4_3D_CAD_MULT_Prod, C_GSE780_52_4_3D_CAD_MULT_Prod:C_GSE780_52_4_3D_CAD_MULT_Prod:152769
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.0121799 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: ___
Identity Data - OmniClass Title: Wood Connectors; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Manufacturer: Simpson Strong-Tie; UniClass Number: Pr_20_85_09_09; OmniClass Number: 23.20.40.11.24.14; Copyright: ©Simpson Strong-Tie; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Bracketed angle supports; URL: www.strongtie.eu
Materials and Finishes - Product Material: Galvanised
General - Density: 0; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: ___; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
