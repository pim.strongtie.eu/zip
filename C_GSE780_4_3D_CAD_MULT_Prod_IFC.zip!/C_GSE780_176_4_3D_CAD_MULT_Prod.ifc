Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-05T09:22:03
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 05 09:22:03 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{E2B5B20C-376C-48E6-8961-BB8DD5FD0CCE}\ifc * Database version: 5507 * Database creation date: Tue Sep 05 09:22:03 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 05 09:22:03 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 05 09:22:03 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\5th 425 Models\Normal Holes\RFA 3D\C_GSE780_176_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Graphics - Symbol at End 1 Default: no; Line Weight: 1; Symbol at End 2 Default: yes; Line Pattern: -3000010; Color: 0

# IfcBuildingElementProxy: C_GSE780_176_4_3D_CAD_MULT_Prod, C_GSE780_176_4_3D_CAD_MULT_Prod:C_GSE780_176_4_3D_CAD_MULT_Prod:191705
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.0121756 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: ___
General - Density: 0; Reference: ___; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - UniClass Number: Pr_20_85_09_09; OmniClass Number: 23.20.40.11.24.14; Provide Feedback: mailto:EUdrawings@strongtie.com; Manufacturer: Simpson Strong-Tie; URL: www.strongtie.eu; Copyright: ©Simpson Strong-Tie; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Title: Bracketed angle supports; OmniClass Title: Wood Connectors
Materials and Finishes - Product Material: Galvanised
