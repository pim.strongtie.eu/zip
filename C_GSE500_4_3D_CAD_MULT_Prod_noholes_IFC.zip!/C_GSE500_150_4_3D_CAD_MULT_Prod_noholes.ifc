Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T12:55:30
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 12:55:30 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{0ADE30A1-3417-4B5F-849C-3ABE148F49BD}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 12:55:30 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 12:55:30 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 12:55:30 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Remove Holes\RFA 3D\GSE500_150_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Line Pattern: -3000010; Symbol at End 1 Default: no; Color: 0; Symbol at End 2 Default: yes; Line Weight: 1
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: GSE500_150_4, GSE500_150_4:GSE500_150_4:196729
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.00798577 ft3
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE500/150/4
Identity Data - Model ID: 0221785887354543700306342353396418465719; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GSE500/150/4; Manufacturer: Simpson Strong-Tie; OmniClass Number: 23.20.40.11.24.14; Name: GSE500/150/4; UniClass Title: Joist hangers; Copyright: ©Simpson Strong-Tie; UniClass Number: Pr_20_29_31_44; OmniClass Title: Wood Connectors; ObjectType: GSE500/150/4; Description: Joist hanger; Product Type: Joist hanger; URL: www.strongtie.eu; Provide Feedback: mailto:EUdrawings@strongtie.com
Materials and Finishes - Product Material: Galvanised
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE500/150/4; Density: 1.69; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD
