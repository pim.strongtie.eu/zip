Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T12:55:40
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 12:55:40 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{B79D1AE9-F02E-4BFC-971A-109ABF258EAB}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 12:55:39 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 12:55:40 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 12:55:40 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Remove Holes\RFA 3D\GSE500_184_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Line Pattern: -3000010; Color: 0; Line Weight: 1
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: GSE500_184_4, GSE500_184_4:GSE500_184_4:207405
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00798577 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE500/184/4
Identity Data - OmniClass Number: 23.20.40.11.24.14; Copyright: ©Simpson Strong-Tie; Product Type: Joist hanger; Model ID: 0221785887354543700306342353396418465719; UniClass Title: Joist hangers; OmniClass Title: Wood Connectors; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; ObjectType: GSE500/184/4; Manufacturer: Simpson Strong-Tie; URL: www.strongtie.eu; Description: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Number: Pr_20_29_31_44; Name: GSE500/184/4; Model: GSE500/184/4
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GSE500/184/4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.69
Materials and Finishes - Product Material: Galvanised
