Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T12:55:17
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 12:55:17 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{1809F5EE-F961-42A1-AE76-47AE817D7568}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 12:55:17 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 12:55:17 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 12:55:17 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Remove Holes\RFA 3D\GSE500_104_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Symbol at End 2 Default: yes; Line Pattern: -3000010; Symbol at End 1 Default: no; Line Weight: 1

# IfcBuildingElementProxy: GSE500_104_4, GSE500_104_4:GSE500_104_4:182285
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00797411 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE500/104/4
Identity Data - UniClass Number: Pr_20_29_31_44; URL: www.strongtie.eu; Model ID: 0144743021757229481494742149328706809534; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Number: 23.20.40.11.24.14; Manufacturer: Simpson Strong-Tie; ObjectType: GSE500/104/4; Product Type: Joist hanger; UniClass Title: Joist hangers; Model: GSE500/104/4; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Title: Wood Connectors; Description: Joist hanger; Copyright: ©Simpson Strong-Tie; Name: GSE500/104/4
General - Density: 1.64; Reference: GSE500/104/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
