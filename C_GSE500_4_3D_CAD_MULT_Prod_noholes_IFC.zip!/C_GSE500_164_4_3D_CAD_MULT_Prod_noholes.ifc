Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T12:55:34
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 12:55:34 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{10432611-572C-47B7-A199-16FB7438BD21}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 12:55:34 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 12:55:34 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 12:55:34 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Remove Holes\RFA 3D\GSE500_164_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Graphics - Color: 0; Line Pattern: -3000010; Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Line Weight: 1

# IfcBuildingElementProxy: GSE500_164_4, GSE500_164_4:GSE500_164_4:201125
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00798577 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE500/164/4
Identity Data - OmniClass Title: Wood Connectors; URL: www.strongtie.eu; UniClass Number: Pr_20_29_31_44; Manufacturer: Simpson Strong-Tie; UniClass Title: Joist hangers; Model: GSE500/164/4; ObjectType: GSE500/164/4; Product Type: Joist hanger; Name: GSE500/164/4; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Description: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Model ID: 0221785887354543700306342353396418465719; Copyright: ©Simpson Strong-Tie; OmniClass Number: 23.20.40.11.24.14
General - Reference: GSE500/164/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.69; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
