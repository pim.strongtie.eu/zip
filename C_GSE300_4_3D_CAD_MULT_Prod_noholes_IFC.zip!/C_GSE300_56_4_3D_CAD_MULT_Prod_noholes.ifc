Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-14T10:22:51
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 14 10:22:51 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{A13BD98C-A395-4CB7-B723-50CBF5E36A9E}\ifc * Database version: 5507 * Database creation date: Fri Jul 14 10:22:51 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 14 10:22:51 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 14 10:22:51 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Remove Holes\RFA 3D\GSE300_56_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Line Weight: 1; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: GSE300_56_4, GSE300_56_4:GSE300_56_4:100645
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00483146 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE300/56/4
Identity Data - OmniClass Title: Wood Connectors; Model ID: 0183248256365066923776616198262381326422; Product Type: Joist hanger; URL: www.strongtie.eu; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Manufacturer: Simpson Strong-Tie; Name: GSE300/56/4; Copyright: ©Simpson Strong-Tie; OmniClass Number: 23.20.40.11.24.14; UniClass Number: Pr_20_29_31_44; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Joist hangers; Model: GSE300/56/4; ObjectType: GSE300/56/4; Description: Joist hanger
General - EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.01; Reference: GSE300/56/4
Materials and Finishes - Product Material: Galvanised
