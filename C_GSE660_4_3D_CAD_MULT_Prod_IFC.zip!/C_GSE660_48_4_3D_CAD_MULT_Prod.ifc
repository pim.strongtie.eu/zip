Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:37:34
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:37:34 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{6675D770-CA28-4CB2-92F1-22F006059B18}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:37:33 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:37:34 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:37:34 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Normal Holes\RFA 3D\C_GSE660_48_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Line Pattern: -3000010; Line Weight: 1; Color: 0; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: C_GSE660_48_4_3D_CAD_MULT_Prod, C_GSE660_48_4_3D_CAD_MULT_Prod:C_GSE660_48_4_3D_CAD_MULT_Prod:204893
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.0103119 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE660/48/4
Identity Data - Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Number: 23.20.40.11.24.14; Name: GSE660/48/4; Product Type: Joist hanger; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GSE660/48/4; Description: Joist hanger; ObjectType: GSE660/48/4; OmniClass Title: Wood Connectors; Model ID: 0063592235211474037397042569254906772418; Manufacturer: Simpson Strong-Tie; UniClass Title: Joist hangers; URL: www.strongtie.eu; Copyright: ©Simpson Strong-Tie; UniClass Number: Pr_20_29_31_44
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 2.14; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE660/48/4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Materials and Finishes - Product Material: Galvanised
