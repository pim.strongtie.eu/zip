Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-17T16:38:16
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 17 16:38:16 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{CA6EF451-FB18-4629-9DA0-A96898D4BE37}\ifc * Database version: 5507 * Database creation date: Mon Jul 17 16:38:16 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 17 16:38:16 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 17 16:38:16 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Normal Holes\RFA 3D\C_GSE340_104_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Weight: 1; Line Pattern: -3000010; Symbol at End 2 Default: yes; Symbol at End 1 Default: no

# IfcBuildingElementProxy: C_GSE340_104_4_3D_CAD_MULT_Prod, C_GSE340_104_4_3D_CAD_MULT_Prod:C_GSE340_104_4_3D_CAD_MULT_Prod:140837
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00540151 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE340/104/4
Identity Data - ObjectType: GSE340/104/4; UniClass Number: Pr_20_29_31_44; URL: www.strongtie.eu; Name: GSE340/104/4; Product Type: Joist hanger; OmniClass Title: Wood Connectors; Manufacturer: Simpson Strong-Tie; UniClass Title: Joist hangers; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Number: 23.20.40.11.24.14; Model ID: 0001266716101628993257122389969939564115; Description: Joist hanger; Model: GSE340/104/4; Copyright: ©Simpson Strong-Tie
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.15; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE340/104/4
Materials and Finishes - Product Material: Galvanised
