Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-17T16:38:11
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 17 16:38:11 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{CAAB179E-D11C-4218-A554-0702431CF382}\ifc * Database version: 5507 * Database creation date: Mon Jul 17 16:38:10 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 17 16:38:11 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 17 16:38:11 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Normal Holes\RFA 3D\C_GSE340_84_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Line Pattern: -3000010; Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Color: 0; Line Weight: 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: C_GSE340_84_4_3D_CAD_MULT_Prod, C_GSE340_84_4_3D_CAD_MULT_Prod:C_GSE340_84_4_3D_CAD_MULT_Prod:134557
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00540147 ft3
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE340/84/4
General - Density: 1.15; Reference: GSE340/84/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
Identity Data - Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Number: 23.20.40.11.24.14; Model: GSE340/84/4; ObjectType: GSE340/84/4; OmniClass Title: Wood Connectors; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Joist hangers; Product Type: Joist hanger; UniClass Number: Pr_20_29_31_44; Manufacturer: Simpson Strong-Tie; URL: www.strongtie.eu; Model ID: 0001266716101628993257122389969939564115; Copyright: ©Simpson Strong-Tie; Name: GSE340/84/4; Description: Joist hanger
