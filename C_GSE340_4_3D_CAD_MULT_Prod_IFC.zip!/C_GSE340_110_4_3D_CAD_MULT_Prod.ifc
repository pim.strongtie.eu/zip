Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-17T16:38:18
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jul 17 16:38:18 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{3163AB95-0E7C-44C4-8CED-CD5BFEDD8DEB}\ifc * Database version: 5507 * Database creation date: Mon Jul 17 16:38:18 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jul 17 16:38:18 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jul 17 16:38:18 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Normal Holes\RFA 3D\C_GSE340_110_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 2 Default: yes; Color: 0; Line Pattern: -3000010; Symbol at End 1 Default: no; Line Weight: 1

# IfcBuildingElementProxy: C_GSE340_110_4_3D_CAD_MULT_Prod, C_GSE340_110_4_3D_CAD_MULT_Prod:C_GSE340_110_4_3D_CAD_MULT_Prod:142721
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.0054032 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE340/110/4
Identity Data - Model: GSE340/110/4; Name: GSE340/110/4; Model ID: 0001266716101628993257122389969939564115; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Manufacturer: Simpson Strong-Tie; Description: Joist hanger; UniClass Number: Pr_20_29_31_44; Product Type: Joist hanger; OmniClass Number: 23.20.40.11.24.14; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Title: Wood Connectors; URL: www.strongtie.eu; UniClass Title: Joist hangers; ObjectType: GSE340/110/4; Copyright: ©Simpson Strong-Tie
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE340/110/4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.15; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
