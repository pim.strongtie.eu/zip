Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T13:14:47
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 13:14:47 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{30D7D767-4B2B-4507-AC45-D4EF1048A410}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 13:14:47 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 13:14:47 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 13:14:47 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Normal Holes\RFA 3D\GSE500_112_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Color: 0; Line Pattern: -3000010; Symbol at End 2 Default: yes; Line Weight: 1

# IfcBuildingElementProxy: GSE500_112_4, GSE500_112_4:GSE500_112_4:184797
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.00785822 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE500/112/4
Identity Data - Product Type: Joist hanger; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; UniClass Number: Pr_20_29_31_44; Name: GSE500/112/4; ObjectType: GSE500/112/4; OmniClass Number: 23.20.40.11.24.14; Model: GSE500/112/4; URL: www.strongtie.eu; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Joist hangers; OmniClass Title: Wood Connectors; Description: Joist hanger; Model ID: 0144743021757229481494742149328706809534; Manufacturer: Simpson Strong-Tie; Copyright: ©Simpson Strong-Tie
General - EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE500/112/4; Density: 1.64; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Materials and Finishes - Product Material: Galvanised
