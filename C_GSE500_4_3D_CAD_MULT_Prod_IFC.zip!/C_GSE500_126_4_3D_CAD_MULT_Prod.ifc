Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T13:14:51
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 13:14:51 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{5477FA37-43B0-4D9F-88C7-5F7F3A22E225}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 13:14:51 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 13:14:51 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 13:14:51 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Normal Holes\RFA 3D\GSE500_126_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Graphics - Line Pattern: -3000010; Line Weight: 1; Color: 0; Symbol at End 2 Default: yes; Symbol at End 1 Default: no

# IfcBuildingElementProxy: GSE500_126_4, GSE500_126_4:GSE500_126_4:189193
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00785822 ft3
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE500/126/4
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.64; Reference: GSE500/126/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD
Identity Data - OmniClass Number: 23.20.40.11.24.14; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Name: GSE500/126/4; OmniClass Title: Wood Connectors; Provide Feedback: mailto:EUdrawings@strongtie.com; ObjectType: GSE500/126/4; Manufacturer: Simpson Strong-Tie; Model: GSE500/126/4; Description: Joist hanger; Copyright: ©Simpson Strong-Tie; Product Type: Joist hanger; UniClass Number: Pr_20_29_31_44; URL: www.strongtie.eu; Model ID: 0144743021757229481494742149328706809534; UniClass Title: Joist hangers
Materials and Finishes - Product Material: Galvanised
