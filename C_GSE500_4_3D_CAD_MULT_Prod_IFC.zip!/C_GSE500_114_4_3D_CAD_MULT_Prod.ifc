Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T13:14:47
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 13:14:47 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{1F883A7F-9CC8-40A0-AE8E-D2F3AF26CE7A}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 13:14:47 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 13:14:47 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 13:14:47 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Normal Holes\RFA 3D\GSE500_114_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Graphics - Symbol at End 1 Default: no; Line Weight: 1; Symbol at End 2 Default: yes; Color: 0; Line Pattern: -3000010

# IfcBuildingElementProxy: GSE500_114_4, GSE500_114_4:GSE500_114_4:185425
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00785822 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE500/114/4
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.64; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE500/114/4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Description: Joist hanger; Model ID: 0144743021757229481494742149328706809534; URL: www.strongtie.eu; Copyright: ©Simpson Strong-Tie; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Product Type: Joist hanger; ObjectType: GSE500/114/4; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; Provide Feedback: mailto:EUdrawings@strongtie.com; Model: GSE500/114/4; Name: GSE500/114/4; OmniClass Number: 23.20.40.11.24.14; Manufacturer: Simpson Strong-Tie; OmniClass Title: Wood Connectors
Materials and Finishes - Product Material: Galvanised
