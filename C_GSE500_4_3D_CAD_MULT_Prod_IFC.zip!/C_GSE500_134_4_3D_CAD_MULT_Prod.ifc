Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T13:14:54
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 13:14:54 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{284AA8FC-D56C-4A5F-80A4-92846092A5A5}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 13:14:53 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 13:14:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 13:14:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Normal Holes\RFA 3D\GSE500_134_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Color: 0; Symbol at End 1 Default: no; Line Pattern: -3000010; Line Weight: 1; Symbol at End 2 Default: yes
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point

# IfcBuildingElementProxy: GSE500_134_4, GSE500_134_4:GSE500_134_4:191705
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00785825 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE500/134/4
Identity Data - Model ID: 0144743021757229481494742149328706809534; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Joist hangers; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Manufacturer: Simpson Strong-Tie; Copyright: ©Simpson Strong-Tie; ObjectType: GSE500/134/4; Product Type: Joist hanger; UniClass Number: Pr_20_29_31_44; Model: GSE500/134/4; OmniClass Title: Wood Connectors; OmniClass Number: 23.20.40.11.24.14; Name: GSE500/134/4; Description: Joist hanger; URL: www.strongtie.eu
General - Density: 1.64; EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GSE500/134/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Materials and Finishes - Product Material: Galvanised
