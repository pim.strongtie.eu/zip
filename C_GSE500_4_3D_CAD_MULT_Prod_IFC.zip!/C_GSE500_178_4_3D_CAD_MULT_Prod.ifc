Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T13:15:07
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 13:15:07 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{E0C9176C-8214-4288-9324-3F4506864B18}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 13:15:07 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 13:15:07 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 13:15:07 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Normal Holes\RFA 3D\GSE500_178_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Symbol at End 1 Default: no; Color: 0; Line Weight: 1; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: GSE500_178_4, GSE500_178_4:GSE500_178_4:205521
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00789095 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE500/178/4
Identity Data - UniClass Title: Joist hangers; Description: Joist hanger; Name: GSE500/178/4; Manufacturer: Simpson Strong-Tie; Product Type: Joist hanger; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; URL: www.strongtie.eu; ObjectType: GSE500/178/4; Model: GSE500/178/4; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Number: 23.20.40.11.24.14; UniClass Number: Pr_20_29_31_44; OmniClass Title: Wood Connectors; Copyright: ©Simpson Strong-Tie; Model ID: 0221785887354543700306342353396418465719
General - Reference: GSE500/178/4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.69; EPD: https://www.strongtie.eu/eu-EU/EPD
Materials and Finishes - Product Material: Galvanised
