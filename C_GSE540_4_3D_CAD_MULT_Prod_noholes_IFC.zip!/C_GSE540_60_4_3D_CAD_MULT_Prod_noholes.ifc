Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:39:43
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:39:43 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{6E20284C-2B6E-4AA0-95FE-1A9BDA4FE57F}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:39:43 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:39:43 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:39:43 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Remove Holes\RFA 3D\C_GSE540_60_4_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Color: 0; Symbol at End 2 Default: yes; Line Weight: 1; Symbol at End 1 Default: no

# IfcBuildingElementProxy: C_GSE540_60_4_3D_CAD_MULT_Prod_noholes, C_GSE540_60_4_3D_CAD_MULT_Prod_noholes:C_GSE540_60_4_3D_CAD_MULT_Prod_noholes:101901
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.0086126 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE540/60/4
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GSE540/60/4; Density: 1.77
Identity Data - Product Type: Joist hanger; Model ID: 0264004639135085779953049290329820303105; Provide Feedback: mailto:EUdrawings@strongtie.com; Name: GSE540/60/4; OmniClass Number: 23.20.40.11.24.14; ObjectType: GSE540/60/4; UniClass Title: Joist hangers; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Copyright: ©Simpson Strong-Tie; Manufacturer: Simpson Strong-Tie; UniClass Number: Pr_20_29_31_44; Model: GSE540/60/4; URL: www.strongtie.eu; Description: Joist hanger; OmniClass Title: Wood Connectors
Materials and Finishes - Product Material: Galvanised
