Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:39:50
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:39:50 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{D04E5773-E606-4060-A039-6951AA193185}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:39:50 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:39:50 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:39:50 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Remove Holes\RFA 3D\C_GSE540_88_4_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Building Story: yes; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Line Weight: 1; Symbol at End 2 Default: yes; Line Pattern: -3000010; Color: 0; Symbol at End 1 Default: no

# IfcBuildingElementProxy: C_GSE540_88_4_3D_CAD_MULT_Prod_noholes, C_GSE540_88_4_3D_CAD_MULT_Prod_noholes:C_GSE540_88_4_3D_CAD_MULT_Prod_noholes:110693
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.0086126 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE540/88/4
Identity Data - Provide Feedback: mailto:EUdrawings@strongtie.com; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Name: GSE540/88/4; URL: www.strongtie.eu; ObjectType: GSE540/88/4; Product Type: Joist hanger; Description: Joist hanger; OmniClass Number: 23.20.40.11.24.14; Manufacturer: Simpson Strong-Tie; Model: GSE540/88/4; Copyright: ©Simpson Strong-Tie; Model ID: 0264004639135085779953049290329820303105; UniClass Title: Joist hangers; OmniClass Title: Wood Connectors; UniClass Number: Pr_20_29_31_44
Materials and Finishes - Product Material: Galvanised
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.77; Reference: GSE540/88/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
