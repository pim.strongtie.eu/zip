Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-09-07T17:13:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 07 17:13:32 2026 * Host: 105VN714 * Database: C:\Users\KHUNGU~1\AppData\Local\Temp\{BC776A25-92A4-449A-A3B8-AD8CB5C5FCBE}\ifc * Database version: 5507 * Database creation date: Mon Sep 07 17:13:32 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 07 17:13:32 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 07 17:13:32 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: \\simpsonmfg.com\Shares\105\Division1\@Technology\3. Customer Facing CAD\BIMCAD EU\ES-226165 BIMCAD EU_47 model first batch\Working\3D no holes\ABR255SO\C_ABR255SO_3D_Cad_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Identity Data - Type Name: Level 1; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: C_ABR255SO_3D_Cad_MULT_Prod, C_ABR255SO_3D_Cad_MULT_Prod:C_ABR255SO_3D_Cad_MULT_Prod:62126
In: Level 1
Type - Material: Galvanised
Type - Constraints - Default Elevation: 0 mm
Type - General - Density: 0.208; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: ABR255SO; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Type - Identity Data - Copyright: ©Simpson Strong-Tie; Description: Angle brackets; Manufacturer: Simpson Strong-Tie; Model: ABR255SO; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0010209404685498371876295931259379817221; Name: ABR255SO; ObjectType: ABR255SO; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Angle brackets; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: C_ABR255SO_3D_Cad_MULT_Prod; UniClass Number: Pr_20_29_31_13; UniClass Title: Carbon steel punched metal plate fasteners; URL: www.strongtie.eu
Type - Materials and Finishes - Product Material: Galvanised
Type - Other - Category: Structural Connections; Family Name: C_ABR255SO_3D_Cad_MULT_Prod
Pset_BuildingElementProxyCommon - Reference: ABR255SO
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm
Dimensions - Volume: 0.000239532 m3
Other - Family: C_ABR255SO_3D_Cad_MULT_Prod: C_ABR255SO_3D_Cad_MULT_Prod; Family and Type: C_ABR255SO_3D_Cad_MULT_Prod: C_ABR255SO_3D_Cad_MULT_Prod; Schedule Level: Level: Level 1; Type: C_ABR255SO_3D_Cad_MULT_Prod: C_ABR255SO_3D_Cad_MULT_Prod; Type Id: C_ABR255SO_3D_Cad_MULT_Prod: C_ABR255SO_3D_Cad_MULT_Prod
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: C_ABR255SO_3D_Cad_MULT_Prod_noholes, C_ABR255SO_3D_Cad_MULT_Prod_noholes:C_ABR255SO_3D_Cad_MULT_Prod_noholes:62864
In: Level 1
Type - Material: Galvanised
Type - Constraints - Default Elevation: 0 mm
Type - General - Density: 0.208; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: ABR255SO; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Type - Identity Data - Copyright: ©Simpson Strong-Tie; Description: Angle brackets; Manufacturer: Simpson Strong-Tie; Model: ABR255SO; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0010209404685498371876295931259379817221; Name: ABR255SO; ObjectType: ABR255SO; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Angle brackets; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: C_ABR255SO_3D_Cad_MULT_Prod_noholes; UniClass Number: Pr_20_29_31_13; UniClass Title: Carbon steel punched metal plate fasteners; URL: www.strongtie.eu
Type - Materials and Finishes - Product Material: Galvanised
Type - Other - Category: Structural Connections; Family Name: C_ABR255SO_3D_Cad_MULT_Prod_noholes
Pset_BuildingElementProxyCommon - Reference: ABR255SO
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm
Dimensions - Volume: 0.000244958 m3
Other - Schedule Level: Level: Level 1; Family: C_ABR255SO_3D_Cad_MULT_Prod_noholes: C_ABR255SO_3D_Cad_MULT_Prod_noholes; Family and Type: C_ABR255SO_3D_Cad_MULT_Prod_noholes: C_ABR255SO_3D_Cad_MULT_Prod_noholes; Type: C_ABR255SO_3D_Cad_MULT_Prod_noholes: C_ABR255SO_3D_Cad_MULT_Prod_noholes; Type Id: C_ABR255SO_3D_Cad_MULT_Prod_noholes: C_ABR255SO_3D_Cad_MULT_Prod_noholes
Phasing - Phase Created: New Construction
