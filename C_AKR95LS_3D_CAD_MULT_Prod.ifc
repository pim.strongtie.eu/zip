Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-09-19T09:24:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 19 09:24:41 2024 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{287A7BCF-5FA3-41A0-A537-25B24B806806}\ifc * Database version: 5507 * Database creation date: Thu Sep 19 09:24:41 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 19 09:24:41 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 19 09:24:41 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-246303 EU BIMCAD for AKR Range\Working\3D Content\Normal Holes\RFA\C_AKR95LS_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: C_AKR95LS_3D_CAD_MULT_Prod, C_AKR95LS_3D_CAD_MULT_Prod:C_AKR95LS_3D_CAD_MULT_Prod:62116
In: Level 1
Material: Stainless steel A4
Pset_BuildingElementProxyCommon - Reference: AKR95LS
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.0000310683 m3
Other - Category: Structural Connections; Family: C_AKR95LS_3D_CAD_MULT_Prod: C_AKR95LS_3D_CAD_MULT_Prod; Family and Type: C_AKR95LS_3D_CAD_MULT_Prod: C_AKR95LS_3D_CAD_MULT_Prod; Schedule Level: Level: Level 1; Type: C_AKR95LS_3D_CAD_MULT_Prod: C_AKR95LS_3D_CAD_MULT_Prod; Type Id: C_AKR95LS_3D_CAD_MULT_Prod: C_AKR95LS_3D_CAD_MULT_Prod; Family Name: C_AKR95LS_3D_CAD_MULT_Prod
Phasing - Phase Created: New Construction
General - Density: 0.243; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: AKR95LS; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Copyright: ©Simpson Strong-Tie; Description: Holdowns; Manufacturer: Simpson Strong-Tie; Model: AKR95LS; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0230072361179524226331545244272880696148; Name: AKR95LS; ObjectType: AKR95LS; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Holdowns; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: C_AKR95LS_3D_CAD_MULT_Prod; UniClass Number: Pr_20_29_31_13; UniClass Title: Carbon steel punched metal plate fasteners; URL: www.strongtie.eu
Materials and Finishes - Product Material: Stainless steel A4
