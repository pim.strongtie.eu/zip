Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T12:54:54
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 12:54:54 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{5C558531-6CE5-46D8-AC99-56BF6FBF94EF}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 12:54:54 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 12:54:54 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 12:54:54 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Remove Holes\RFA 3D\GSE440_132_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Pattern: -3000010; Line Weight: 1; Color: 0

# IfcBuildingElementProxy: GSE440_132_4, GSE440_132_4:GSE440_132_4:157793
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00701637 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE440/132/4
Identity Data - UniClass Title: Joist hangers; Manufacturer: Simpson Strong-Tie; OmniClass Number: 23.20.40.11.24.14; URL: www.strongtie.eu; Copyright: ©Simpson Strong-Tie; Model: GSE440/132/4; ObjectType: GSE440/132/4; Description: Joist hanger; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0106845967910967583169462323905988993325; Product Type: Joist hanger; UniClass Number: Pr_20_29_31_44; OmniClass Title: Wood Connectors; Name: GSE440/132/4; Provide Feedback: mailto:EUdrawings@strongtie.com
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GSE440/132/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.45
Materials and Finishes - Product Material: Galvanised
