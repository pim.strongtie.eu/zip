Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2025-05-23T15:39:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri May 23 15:39:53 2025 * Host: 105VN589 * Database: C:\Users\truole\AppData\Local\Temp\{7D7840AB-98FE-46B6-B9D7-2CAB9E1CADA6}\ifc * Database version: 5507 * Database creation date: Fri May 23 15:39:53 2025 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri May 23 15:39:53 2025 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri May 23 15:39:53 2025 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: D:\ES-25042678 EU BIM drawings for Various UK products _SES etc\3D Contents\Remove hole\RFA 3D\SES318_45.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: SES318_45, SES318_45:SES318_45:97788
In: Level 1
Material: Galvanised
Pset_BuildingElementProxyCommon - Reference: SES318/45
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.0000237768 m3
Other - Category: Structural Connections; Family: SES318_45: SES318_45; Family and Type: SES318_45: SES318_45; Schedule Level: Level: Level 1; Type: SES318_45: SES318_45; Type Id: SES318_45: SES318_45; Family Name: SES318_45
Phasing - Phase Created: New Construction
General - Density: 0.01; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: SES318/45; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Copyright: ©Simpson Strong-Tie; Description: Connector Other; Manufacturer: Simpson Strong-Tie; Model: SES318/45; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: #; Name: SES318/45; ObjectType: SES318/45; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Connector Other; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: SES318_45; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; URL: www.strongtie.eu
Materials and Finishes - Product Material: Galvanised
