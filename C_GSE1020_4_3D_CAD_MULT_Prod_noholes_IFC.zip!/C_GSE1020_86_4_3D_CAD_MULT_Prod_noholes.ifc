Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-14T10:23:38
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 14 10:23:38 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{572EF727-C803-4C52-AFC2-29FFFFF06E2B}\ifc * Database version: 5507 * Database creation date: Fri Jul 14 10:23:38 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 14 10:23:38 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 14 10:23:38 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Remove Holes\RFA 3D\GSE1020_86_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 2 Default: yes; Line Weight: 1; Color: 0; Line Pattern: -3000010; Symbol at End 1 Default: no

# IfcBuildingElementProxy: GSE1020_86_4, GSE1020_86_4:GSE1020_86_4:160305
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.0162374 ft3
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE1020/86/4
Identity Data - Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GSE1020/86/4; Name: GSE1020/86/4; Copyright: ©Simpson Strong-Tie; OmniClass Number: 23.20.40.11.24.14; Product Type: Joist hanger; OmniClass Title: Wood Connectors; ObjectType: GSE1020/86/4; Manufacturer: Simpson Strong-Tie; Model ID: 0021453351274842237233275995356361797366; URL: www.strongtie.eu; UniClass Title: Joist hangers; UniClass Number: Pr_20_29_31_44; Provide Feedback: mailto:EUdrawings@strongtie.com; Description: Joist hanger
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 3.4; Reference: GSE1020/86/4
Materials and Finishes - Product Material: Galvanised
