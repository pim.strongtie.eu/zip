Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-14T10:23:27
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 14 10:23:27 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{395A6031-AD31-47AE-A1F9-33A867B3561F}\ifc * Database version: 5507 * Database creation date: Fri Jul 14 10:23:27 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 14 10:23:27 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 14 10:23:27 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Remove Holes\RFA 3D\GSE1020_40_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Graphics - Symbol at End 1 Default: no; Line Weight: 1; Symbol at End 2 Default: yes; Color: 0; Line Pattern: -3000010

# IfcBuildingElementProxy: GSE1020_40_4, GSE1020_40_4:GSE1020_40_4:145861
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.0162374 ft3
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE1020/40/4
Materials and Finishes - Product Material: Galvanised
Identity Data - ObjectType: GSE1020/40/4; OmniClass Title: Wood Connectors; Product Type: Joist hanger; Description: Joist hanger; UniClass Number: Pr_20_29_31_44; Name: GSE1020/40/4; URL: www.strongtie.eu; Model ID: 0021453351274842237233275995356361797366; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Manufacturer: Simpson Strong-Tie; Model: GSE1020/40/4; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Joist hangers; OmniClass Number: 23.20.40.11.24.14; Copyright: ©Simpson Strong-Tie
General - Reference: GSE1020/40/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 3.4
