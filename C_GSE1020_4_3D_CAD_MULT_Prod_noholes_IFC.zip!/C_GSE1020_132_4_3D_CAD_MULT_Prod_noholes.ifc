Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-14T10:23:51
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 14 10:23:51 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{FE2CAFC0-81AC-426E-AD07-E20FC3F14C18}\ifc * Database version: 5507 * Database creation date: Fri Jul 14 10:23:51 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 14 10:23:51 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 14 10:23:51 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Remove Holes\RFA 3D\GSE1020_132_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Graphics - Line Pattern: -3000010; Line Weight: 1; Color: 0; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: GSE1020_132_4, GSE1020_132_4:GSE1020_132_4:174749
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.0162374 ft3
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE1020/132/4
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 3.4; Reference: GSE1020/132/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD
Identity Data - UniClass Number: Pr_20_29_31_44; ObjectType: GSE1020/132/4; OmniClass Number: 23.20.40.11.24.14; Description: Joist hanger; UniClass Title: Joist hangers; Manufacturer: Simpson Strong-Tie; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Copyright: ©Simpson Strong-Tie; Product Type: Joist hanger; Name: GSE1020/132/4; URL: www.strongtie.eu; Model ID: 0021453351274842237233275995356361797366; Provide Feedback: mailto:EUdrawings@strongtie.com; Model: GSE1020/132/4; OmniClass Title: Wood Connectors
Materials and Finishes - Product Material: Galvanised
