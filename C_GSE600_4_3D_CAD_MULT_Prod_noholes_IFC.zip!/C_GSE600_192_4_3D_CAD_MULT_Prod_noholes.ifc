Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:41:08
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:41:08 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{ADA8D4D6-5069-4926-A900-40649DB95996}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:41:08 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:41:08 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:41:08 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Remove Holes\RFA 3D\C_GSE600_192_4_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Graphics - Symbol at End 1 Default: no; Line Pattern: -3000010; Symbol at End 2 Default: yes; Color: 0; Line Weight: 1

# IfcBuildingElementProxy: C_GSE600_192_4_3D_CAD_MULT_Prod_noholes, C_GSE600_192_4_3D_CAD_MULT_Prod_noholes:C_GSE600_192_4_3D_CAD_MULT_Prod_noholes:196729
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.0095449 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE600/192/4
Identity Data - Manufacturer: Simpson Strong-Tie; OmniClass Number: 23.20.40.11.24.14; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Provide Feedback: mailto:EUdrawings@strongtie.com; Description: Joist hanger; Model ID: 0193558067862976383730932520430441780132; OmniClass Title: Wood Connectors; ObjectType: GSE600/192/4; Name: GSE600/192/4; Copyright: ©Simpson Strong-Tie; URL: www.strongtie.eu; Model: GSE600/192/4; Product Type: Joist hanger; UniClass Title: Joist hangers; UniClass Number: Pr_20_29_31_44
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GSE600/192/4; Density: 2
Materials and Finishes - Product Material: Galvanised
