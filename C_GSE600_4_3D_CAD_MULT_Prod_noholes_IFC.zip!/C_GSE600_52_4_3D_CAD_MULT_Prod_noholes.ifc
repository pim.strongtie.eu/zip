Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:40:29
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:40:29 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{3ED0A8BB-EF4C-455E-9283-6D7A9E297A4E}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:40:29 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:40:29 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:40:29 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Remove Holes\RFA 3D\C_GSE600_52_4_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Symbol at End 1 Default: no; Line Weight: 1; Color: 0; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: C_GSE600_52_4_3D_CAD_MULT_Prod_noholes, C_GSE600_52_4_3D_CAD_MULT_Prod_noholes:C_GSE600_52_4_3D_CAD_MULT_Prod_noholes:152769
In: Level 1
Material: Galvanised
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00957033 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE600/52/4
Identity Data - UniClass Number: Pr_20_29_31_44; Model ID: 0278878673117064837391667061842868427601; UniClass Title: Joist hangers; Manufacturer: Simpson Strong-Tie; Description: Joist hanger; Name: GSE600/52/4; OmniClass Title: Wood Connectors; Model: GSE600/52/4; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Product Type: Joist hanger; ObjectType: GSE600/52/4; OmniClass Number: 23.20.40.11.24.14; Provide Feedback: mailto:EUdrawings@strongtie.com; Copyright: ©Simpson Strong-Tie; URL: www.strongtie.eu
Materials and Finishes - Product Material: Galvanised
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GSE600/52/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.96
