Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:40:41
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:40:41 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{F39C9E54-7A61-45DD-827E-3F873B931F7A}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:40:41 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:40:41 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:40:41 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Remove Holes\RFA 3D\C_GSE600_94_4_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Line Weight: 1; Line Pattern: -3000010; Symbol at End 2 Default: yes; Color: 0; Symbol at End 1 Default: no

# IfcBuildingElementProxy: C_GSE600_94_4_3D_CAD_MULT_Prod_noholes, C_GSE600_94_4_3D_CAD_MULT_Prod_noholes:C_GSE600_94_4_3D_CAD_MULT_Prod_noholes:165957
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00957033 ft3
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE600/94/4
Identity Data - Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GSE600/94/4; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; ObjectType: GSE600/94/4; Provide Feedback: mailto:EUdrawings@strongtie.com; Model ID: 0278878673117064837391667061842868427601; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; OmniClass Title: Wood Connectors; Name: GSE600/94/4; Product Type: Joist hanger; OmniClass Number: 23.20.40.11.24.14; Copyright: ©Simpson Strong-Tie; URL: www.strongtie.eu
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GSE600/94/4; Density: 1.96; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Materials and Finishes - Product Material: Galvanised
