Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:40:49
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:40:49 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{15BBC559-703F-4C51-A0C8-F87374BC5A4D}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:40:49 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:40:49 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:40:49 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Remove Holes\RFA 3D\C_GSE600_124_4_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Weight: 1; Color: 0; Line Pattern: -3000010

# IfcBuildingElementProxy: C_GSE600_124_4_3D_CAD_MULT_Prod_noholes, C_GSE600_124_4_3D_CAD_MULT_Prod_noholes:C_GSE600_124_4_3D_CAD_MULT_Prod_noholes:175377
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00957033 ft3
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE600/124/4
Identity Data - OmniClass Title: Wood Connectors; UniClass Title: Joist hangers; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Manufacturer: Simpson Strong-Tie; Copyright: ©Simpson Strong-Tie; URL: www.strongtie.eu; UniClass Number: Pr_20_29_31_44; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Number: 23.20.40.11.24.14; Model ID: 0278878673117064837391667061842868427601; Description: Joist hanger; ObjectType: GSE600/124/4; Name: GSE600/124/4; Model: GSE600/124/4; Product Type: Joist hanger
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE600/124/4; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.96; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Materials and Finishes - Product Material: Galvanised
