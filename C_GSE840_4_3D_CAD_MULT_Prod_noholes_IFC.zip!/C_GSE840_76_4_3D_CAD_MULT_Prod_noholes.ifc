Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-14T15:21:24
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 14 15:21:24 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{4E6505AD-B5EB-4B55-B095-9447E5C2754B}\ifc * Database version: 5507 * Database creation date: Thu Sep 14 15:21:24 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 14 15:21:24 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 14 15:21:24 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Final Documents\2023-9-13 the last 255 models of batch 1.3\3D Contents\Remove Holes\C_GSE840_76_4_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Line Weight: 1; Color: 0; Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Line Pattern: -3000010

# IfcBuildingElementProxy: C_GSE840_76_4_3D_CAD_MULT_Prod_noholes, C_GSE840_76_4_3D_CAD_MULT_Prod_noholes:C_GSE840_76_4_3D_CAD_MULT_Prod_noholes:106906
In: Level 1
Material: Galvanized
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.0133642 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie Company Inc.
Pset_BuildingElementProxyCommon - Reference: C_GSE840_76_4_3D_CAD_MULT_Prod_noholes
Identity Data - Model Disclaimer: Contact Simpson Strong-Tie Company Inc. for more information; Model: GSE840/76/4; Product Type: Joist hanger; URL: http://www.strongtie.com/; Manufacturer: Simpson Strong-Tie Company Inc.; Provide Feedback: http://www.strongtie.com/drawings/revit_request.asp; Model ID: 0273535979702676255630551703997216975884; Copyright: ©Simpson Strong-Tie
Materials and Finishes - Product Material: Galvanized
