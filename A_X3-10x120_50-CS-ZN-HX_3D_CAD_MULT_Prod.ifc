Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture]
Time: 2026-05-29T13:57:52
Author: KhuNguyen
Written by: EDMsix Version 602.28.129 Aug 2 2022
Made in: AutoCAD Architecture 2024 - English Build 8.6.52.0
Comment: STEP Physical File produced by: EDMsix Version 602.28.129 Aug 2 2022 * Module: EDMstepFileFactory v4.0.1/EDMstandAlone * Creation date: 20260529 13:57:52 * Host: 105VN714.simpsonmfg.com * Database: C:\Users\KHUNGU~1\AppData\Local\Temp\ACAIFCTMP/EDM64504\aec_ifc_db * Database version: 6007 * Database creation date: Fri May 29 13:53:57 2026 * Schema: IFC2X3 * Model: DataRepository.AecIfc * Model creation date: Fri May 29 13:57:52 2026 * Header model: DataRepository.AecIfc_Header * Header model creation date: Fri May 29 13:57:52 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 10522 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, ifc
LongName: X3-10x120_50-CS-ZN-HX
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Model

# IfcBuilding, X3-10x120_50-CS-ZN-HX
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0
