Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-08-28T15:42:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 28 15:42:22 2026 * Host: 105VN714 * Database: C:\Users\KHUNGU~1\AppData\Local\Temp\{9FD0D2D6-DA89-4EB6-847A-F3A446A08D05}\ifc * Database version: 5507 * Database creation date: Fri Aug 28 15:42:21 2026 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 28 15:42:21 2026 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 28 15:42:21 2026 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: D:\BIMCAD EU\ES-26080486 EU BIM files for Missing angle brackets\3D Contents - Normal Holes\RFA 3D\C_ADR6035_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: C_ADR6035_3D_CAD_MULT_Prod, C_ADR6035_3D_CAD_MULT_Prod:C_ADR6035_3D_CAD_MULT_Prod:77416
In: Level 1
Type - Material: Galvanised
Type - Constraints - Default Elevation: 0 mm
Type - General - Density: 0.1; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: ADR6035; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Type - Identity Data - Copyright: ©Simpson Strong-Tie; Description: Angle brackets; Manufacturer: Simpson Strong-Tie; Model: ADR6035; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0160989268046201237703313634578035460513; Name: ADR6035; ObjectType: ADR6035; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Angle brackets; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: C_ADR6035_3D_CAD_MULT_Prod; UniClass Number: Pr_20_85_09_09; UniClass Title: Bracketed angle supports; URL: www.strongtie.eu
Type - Materials and Finishes - Product Material: Galvanised
Type - Other - Category: Structural Connections; Family Name: C_ADR6035_3D_CAD_MULT_Prod
Pset_BuildingElementProxyCommon - Reference: ADR6035
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm
Dimensions - Volume: 0.0000133091 m3
Other - Family: C_ADR6035_3D_CAD_MULT_Prod: C_ADR6035_3D_CAD_MULT_Prod; Family and Type: C_ADR6035_3D_CAD_MULT_Prod: C_ADR6035_3D_CAD_MULT_Prod; Schedule Level: Level: Level 1; Type: C_ADR6035_3D_CAD_MULT_Prod: C_ADR6035_3D_CAD_MULT_Prod; Type Id: C_ADR6035_3D_CAD_MULT_Prod: C_ADR6035_3D_CAD_MULT_Prod
Phasing - Phase Created: New Construction
