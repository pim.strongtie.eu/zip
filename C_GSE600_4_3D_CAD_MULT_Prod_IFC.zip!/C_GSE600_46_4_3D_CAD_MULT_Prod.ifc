Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:36:27
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:36:27 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{41A89E73-3816-448C-9236-747FC973789B}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:36:26 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:36:27 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:36:27 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Normal Holes\RFA 3D\C_GSE600_46_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Symbol at End 2 Default: yes; Color: 0; Line Weight: 1; Line Pattern: -3000010; Symbol at End 1 Default: no
Dimensions - Computation Height: 0 mm
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Identity Data - Building Story: yes; Structural: no; Name: Level 1

# IfcBuildingElementProxy: C_GSE600_46_4_3D_CAD_MULT_Prod, C_GSE600_46_4_3D_CAD_MULT_Prod:C_GSE600_46_4_3D_CAD_MULT_Prod:150885
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.0094123 ft3
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE600/46/4
Identity Data - Model Disclaimer: Contact Simpson Strong-Tie Company for more information; OmniClass Number: 23.20.40.11.24.14; URL: www.strongtie.eu; Manufacturer: Simpson Strong-Tie; Product Type: Joist hanger; Description: Joist hanger; UniClass Title: Joist hangers; Provide Feedback: mailto:EUdrawings@strongtie.com; Model ID: 0278878673117064837391667061842868427601; UniClass Number: Pr_20_29_31_44; Model: GSE600/46/4; Name: GSE600/46/4; Copyright: ©Simpson Strong-Tie; OmniClass Title: Wood Connectors; ObjectType: GSE600/46/4
General - EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE600/46/4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Density: 1.96
Materials and Finishes - Product Material: Galvanised
