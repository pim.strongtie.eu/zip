Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-09-12T12:53:19
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Sep 12 12:53:19 2024 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{D9F4EB02-5373-4E42-9936-CE6C273321CA}\ifc * Database version: 5507 * Database creation date: Thu Sep 12 12:53:19 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Sep 12 12:53:19 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Sep 12 12:53:19 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-245857 EU BIMCAD for HJHM-HJHMI Range\Working\3D Contents\Remove Holes\RFA 3D\C_HJHMI373_99_3D_CAD_MULT_Prod_noholes.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: C_HJHMI373_99_3D_CAD_MULT_Prod_noholes, C_HJHMI373_99_3D_CAD_MULT_Prod_noholes:C_HJHMI373_99_3D_CAD_MULT_Prod_noholes:134187
In: Level 1
Material: Galvanised
Pset_BuildingElementProxyCommon - Reference: HJHMI373/99
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.000425914 m3
Other - Category: Structural Connections; Family: C_HJHMI373_99_3D_CAD_MULT_Prod_noholes: C_HJHMI373_99_3D_CAD_MULT_Prod_noholes; Family and Type: C_HJHMI373_99_3D_CAD_MULT_Prod_noholes: C_HJHMI373_99_3D_CAD_MULT_Prod_noholes; Schedule Level: Level: Level 1; Type: C_HJHMI373_99_3D_CAD_MULT_Prod_noholes: C_HJHMI373_99_3D_CAD_MULT_Prod_noholes; Type Id: C_HJHMI373_99_3D_CAD_MULT_Prod_noholes: C_HJHMI373_99_3D_CAD_MULT_Prod_noholes; Family Name: C_HJHMI373_99_3D_CAD_MULT_Prod_noholes
Phasing - Phase Created: New Construction
General - Density: 3.452; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: HJHMI373/99; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Copyright: ©Simpson Strong-Tie; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; Model: HJHMI373/99; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0156037274424648118349808998919535080654; Name: HJHMI373/99; ObjectType: HJHMI373/99; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: C_HJHMI373_99_3D_CAD_MULT_Prod_noholes; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; URL: www.strongtie.eu
Materials and Finishes - Product Material: Galvanised
