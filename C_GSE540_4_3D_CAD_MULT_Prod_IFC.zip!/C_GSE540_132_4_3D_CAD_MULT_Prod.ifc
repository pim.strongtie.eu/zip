Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:35:57
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:35:57 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{AEEB4E0F-ADD6-4250-B1E7-948FDC9A16D7}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:35:57 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:35:57 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:35:57 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Normal Holes\RFA 3D\C_GSE540_132_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Graphics - Symbol at End 2 Default: yes; Color: 0; Symbol at End 1 Default: no; Line Pattern: -3000010; Line Weight: 1

# IfcBuildingElementProxy: C_GSE540_132_4_3D_CAD_MULT_Prod, C_GSE540_132_4_3D_CAD_MULT_Prod:C_GSE540_132_4_3D_CAD_MULT_Prod:124509
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.0084809 ft3
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE540/132/4
Materials and Finishes - Product Material: Galvanised
Identity Data - Model: GSE540/132/4; Name: GSE540/132/4; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; ObjectType: GSE540/132/4; OmniClass Number: 23.20.40.11.24.14; Manufacturer: Simpson Strong-Tie; Description: Joist hanger; Product Type: Joist hanger; OmniClass Title: Wood Connectors; UniClass Number: Pr_20_29_31_44; Copyright: ©Simpson Strong-Tie; Model ID: 0264004639135085779953049290329820303105; Provide Feedback: mailto:EUdrawings@strongtie.com; URL: www.strongtie.eu; UniClass Title: Joist hangers
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; Reference: GSE540/132/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Density: 1.77
