Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:35:47
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:35:47 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{D2B5F494-EA49-4D8B-B25A-A9FF2B40416F}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:35:47 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:35:47 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:35:47 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Normal Holes\RFA 3D\C_GSE540_102_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Symbol at End 2 Default: yes; Line Pattern: -3000010; Color: 0; Line Weight: 1; Symbol at End 1 Default: no
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: C_GSE540_102_4_3D_CAD_MULT_Prod, C_GSE540_102_4_3D_CAD_MULT_Prod:C_GSE540_102_4_3D_CAD_MULT_Prod:115089
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.0084809 ft3
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE540/102/4
General - Density: 1.77; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GSE540/102/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Provide Feedback: mailto:EUdrawings@strongtie.com; Model: GSE540/102/4; OmniClass Title: Wood Connectors; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; URL: www.strongtie.eu; UniClass Number: Pr_20_29_31_44; Product Type: Joist hanger; Description: Joist hanger; OmniClass Number: 23.20.40.11.24.14; Name: GSE540/102/4; UniClass Title: Joist hangers; Manufacturer: Simpson Strong-Tie; ObjectType: GSE540/102/4; Model ID: 0264004639135085779953049290329820303105; Copyright: ©Simpson Strong-Tie
Materials and Finishes - Product Material: Galvanised
