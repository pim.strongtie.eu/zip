Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:36:14
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:36:14 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{2A42D442-4C42-4D27-B951-000CE19ED30E}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:36:14 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:36:14 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:36:14 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Normal Holes\RFA 3D\C_GSE540_184_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 1 Default: no; Color: 0; Line Pattern: -3000010; Symbol at End 2 Default: yes; Line Weight: 1

# IfcBuildingElementProxy: C_GSE540_184_4_3D_CAD_MULT_Prod, C_GSE540_184_4_3D_CAD_MULT_Prod:C_GSE540_184_4_3D_CAD_MULT_Prod:140837
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00847655 ft3
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE540/184/4
Identity Data - Product Type: Joist hanger; ObjectType: GSE540/184/4; URL: www.strongtie.eu; UniClass Number: Pr_20_29_31_44; Manufacturer: Simpson Strong-Tie; Name: GSE540/184/4; OmniClass Title: Wood Connectors; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Provide Feedback: mailto:EUdrawings@strongtie.com; OmniClass Number: 23.20.40.11.24.14; Copyright: ©Simpson Strong-Tie; UniClass Title: Joist hangers; Model: GSE540/184/4; Model ID: 0054837501595047816322057390104786965640; Description: Joist hanger
General - EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 1.81; Reference: GSE540/184/4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Materials and Finishes - Product Material: Galvanised
