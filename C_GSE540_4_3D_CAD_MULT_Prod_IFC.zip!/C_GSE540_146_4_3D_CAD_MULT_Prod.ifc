Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:36:02
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:36:02 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{5CF8788B-E899-48E6-9E7B-3B735E7F776C}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:36:02 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:36:02 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:36:02 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Normal Holes\RFA 3D\C_GSE540_146_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Name: Level 1; Building Story: yes
Graphics - Color: 0; Line Pattern: -3000010; Symbol at End 2 Default: yes; Line Weight: 1; Symbol at End 1 Default: no

# IfcBuildingElementProxy: C_GSE540_146_4_3D_CAD_MULT_Prod, C_GSE540_146_4_3D_CAD_MULT_Prod:C_GSE540_146_4_3D_CAD_MULT_Prod:128905
In: Level 1
Material: Galvanised
Dimensions - Volume: 0.00847655 ft3
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE540/146/4
Identity Data - Description: Joist hanger; UniClass Title: Joist hangers; Manufacturer: Simpson Strong-Tie; Model ID: 0054837501595047816322057390104786965640; ObjectType: GSE540/146/4; Copyright: ©Simpson Strong-Tie; Product Type: Joist hanger; OmniClass Title: Wood Connectors; OmniClass Number: 23.20.40.11.24.14; Name: GSE540/146/4; URL: www.strongtie.eu; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Number: Pr_20_29_31_44; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model: GSE540/146/4
General - Density: 1.81; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GSE540/146/4; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking
Materials and Finishes - Product Material: Galvanised
