Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-08-24T09:35:39
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 24 09:35:39 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{AD44B34F-4BB0-42CD-85DC-0B62C5E7CDB7}\ifc * Database version: 5507 * Database creation date: Thu Aug 24 09:35:39 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 24 09:35:39 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 24 09:35:39 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\4nd 255 Models\Normal Holes\RFA 3D\C_GSE540_82_4_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Symbol at End 2 Default: yes; Line Weight: 1; Color: 0; Symbol at End 1 Default: no

# IfcBuildingElementProxy: C_GSE540_82_4_3D_CAD_MULT_Prod, C_GSE540_82_4_3D_CAD_MULT_Prod:C_GSE540_82_4_3D_CAD_MULT_Prod:108809
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.0084809 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE540/82/4
Identity Data - Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Provide Feedback: mailto:EUdrawings@strongtie.com; URL: www.strongtie.eu; UniClass Title: Joist hangers; Product Type: Joist hanger; ObjectType: GSE540/82/4; Model: GSE540/82/4; Copyright: ©Simpson Strong-Tie; UniClass Number: Pr_20_29_31_44; OmniClass Title: Wood Connectors; Manufacturer: Simpson Strong-Tie; Model ID: 0264004639135085779953049290329820303105; OmniClass Number: 23.20.40.11.24.14; Description: Joist hanger; Name: GSE540/82/4
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE540/82/4; Density: 1.77
Materials and Finishes - Product Material: Galvanised
