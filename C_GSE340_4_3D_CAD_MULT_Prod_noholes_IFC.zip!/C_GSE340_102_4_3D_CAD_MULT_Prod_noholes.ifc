Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-14T10:23:22
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 14 10:23:22 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{CFC15E6B-E33A-43A7-807D-D7ABA6D1F647}\ifc * Database version: 5507 * Database creation date: Fri Jul 14 10:23:22 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 14 10:23:22 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 14 10:23:22 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Remove Holes\RFA 3D\GSE340_102_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Line Pattern: -3000010; Color: 0; Symbol at End 2 Default: yes; Symbol at End 1 Default: no; Line Weight: 1

# IfcBuildingElementProxy: GSE340_102_4, GSE340_102_4:GSE340_102_4:140209
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00546995 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE340/102/4
Identity Data - Copyright: ©Simpson Strong-Tie; ObjectType: GSE340/102/4; Manufacturer: Simpson Strong-Tie; Name: GSE340/102/4; OmniClass Title: Wood Connectors; URL: www.strongtie.eu; Model: GSE340/102/4; OmniClass Number: 23.20.40.11.24.14; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; Model ID: 0001266716101628993257122389969939564115; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Provide Feedback: mailto:EUdrawings@strongtie.com; Product Type: Joist hanger; Description: Joist hanger
General - ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GSE340/102/4; Density: 1.15
Materials and Finishes - Product Material: Galvanised
