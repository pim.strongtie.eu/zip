Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-14T10:23:21
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 14 10:23:21 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{F9B18177-A643-4280-9257-B13BA9723523}\ifc * Database version: 5507 * Database creation date: Fri Jul 14 10:23:21 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 14 10:23:21 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 14 10:23:21 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\2nd 165 Models\Remove Holes\RFA 3D\GSE340_98_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 2 Default: yes; Color: 0; Symbol at End 1 Default: no; Line Pattern: -3000010; Line Weight: 1

# IfcBuildingElementProxy: GSE340_98_4, GSE340_98_4:GSE340_98_4:138953
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Other - Schedule Level: Level: Level 1
Dimensions - Volume: 0.00546995 ft3
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE340/98/4
Identity Data - OmniClass Title: Wood Connectors; URL: www.strongtie.eu; UniClass Title: Joist hangers; Model ID: 0001266716101628993257122389969939564115; Name: GSE340/98/4; ObjectType: GSE340/98/4; Description: Joist hanger; Model: GSE340/98/4; OmniClass Number: 23.20.40.11.24.14; UniClass Number: Pr_20_29_31_44; Product Type: Joist hanger; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Copyright: ©Simpson Strong-Tie; Provide Feedback: mailto:EUdrawings@strongtie.com; Manufacturer: Simpson Strong-Tie
Materials and Finishes - Product Material: Galvanised
General - Density: 1.15; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GSE340/98/4
