Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-07-26T12:54:09
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 26 12:54:09 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{971C3B01-AD69-4480-AE5F-71C562A99471}\ifc * Database version: 5507 * Database creation date: Wed Jul 26 12:54:09 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 26 12:54:09 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 26 12:54:09 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-233601 BIMCAD EU_Batch 1.3_1191 models\Working\3D Content\3rd 191 Models\Remove Holes\RFA 3D\GSE380_66_4.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Graphics - Symbol at End 2 Default: yes; Line Pattern: -3000010; Line Weight: 1; Symbol at End 1 Default: no; Color: 0

# IfcBuildingElementProxy: GSE380_66_4, GSE380_66_4:GSE380_66_4:103785
In: Level 1
Material: Galvanised
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.00605864 ft3
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GSE380/66/4
General - Density: 1.25; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD; Reference: GSE380/66/4; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - URL: www.strongtie.eu; OmniClass Number: 23.20.40.11.24.14; Model ID: 0167559818778083327613004514442237464453; Model: GSE380/66/4; Description: Joist hanger; OmniClass Title: Wood Connectors; Name: GSE380/66/4; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; UniClass Title: Joist hangers; ObjectType: GSE380/66/4; Copyright: ©Simpson Strong-Tie; Manufacturer: Simpson Strong-Tie; UniClass Number: Pr_20_29_31_44
Materials and Finishes - Product Material: Galvanised
